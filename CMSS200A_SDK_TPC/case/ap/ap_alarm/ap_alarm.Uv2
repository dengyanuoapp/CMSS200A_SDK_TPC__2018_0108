### uVision2 Project, (C) Keil Software
### Do not modify !

Target (alarm), 0x0001 // Tools: 'MCS-251'

Group (cfg)
Group (alarm)
Group (lib)
Group (lst)
Group (com_res)
Group (com_message)

File 1,5,<.\ap_alarm.apc><ap_alarm.apc>
File 1,5,<.\buildap.bat><buildap.bat>
File 1,5,<.\buildapl.bat><buildapl.bat>
File 1,5,<.\ap_alarm.lin><ap_alarm.lin>
File 1,5,<.\ap_alarm.apl><ap_alarm.apl>
File 2,1,<.\alarm_main.c><alarm_main.c>
File 2,1,<.\alarm_play.c><alarm_play.c>
File 3,4,<..\..\..\psp_rel\lib\LIBC.LIB><LIBC.LIB>
File 3,4,<..\..\..\psp_rel\lib\TYPE_CHECK_MP3.LIB><TYPE_CHECK_MP3.LIB>
File 3,4,<..\..\..\psp_rel\lib\BASAL_DECODE.LIB><BASAL_DECODE.LIB>
File 3,4,<..\..\..\psp_rel\lib\BASAL_ENCODE.LIB><BASAL_ENCODE.LIB>
File 3,4,<..\..\..\psp_rel\lib\TYPE_CHECK_WMA.LIB><TYPE_CHECK_WMA.LIB>
File 3,4,<..\..\..\psp_rel\lib\TYPE_CHECK_WAV.LIB><TYPE_CHECK_WAV.LIB>
File 3,4,<..\..\..\psp_rel\lib\CODEC_DEC_VERIFY.LIB><CODEC_DEC_VERIFY.LIB>
File 3,4,<..\..\..\psp_rel\lib\CODEC_ENC_VERIFY.LIB><CODEC_ENC_VERIFY.LIB>
File 3,4,<..\..\..\psp_rel\lib\APDftSeg.lib><APDftSeg.lib>
File 3,4,<..\..\..\psp_rel\lib\actos30api.LIB><actos30api.LIB>
File 3,4,<..\..\lib\displayapi.LIB><displayapi.LIB>
File 3,4,<..\..\..\psp_rel\lib\BASAL_DECODE_SD.LIB><BASAL_DECODE_SD.LIB>
File 4,5,<.\ap_alarm.map><ap_alarm.map>
File 5,1,<..\common\ap_common.c><ap_common.c>
File 5,1,<..\common\ap_common2.c><ap_common2.c>
File 6,1,<..\common\ap_message.c><ap_message.c>
File 6,1,<..\common\ap_message2.c><ap_message2.c>


Options 1,0,0  // Target 'alarm'
 Device (Flip80251 Typhoon)
 Vendor (Dolphin)
 Cpu (IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF))
 FlashUt ()
 StupF ("LIB\START251.A51" ("Standard 251 Startup Code"))
 FlashDR ()
 DevID (3644)
 Rgf (REG251S.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin (C:\Keil\C251\BIN\)
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ÿIntel\)
 TgStat=16
 OutDir (.\Obj\)
 OutName (ap_alarm)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\Lst\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 1 <.\buildap.bat>
 RunUsr 1 0 <>
 BrunUsr 0 1 <.\buildapl.bat>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 MODEL25=3
 RTOS25=0
 ROMSZ25=4
 DHOLD25=0
 XHOLD25=0
 FHOLD25=0
 T251FL=92
 CBANKS2=0
 RCB25 { 0,0,0,0,0,0,0,1,0 }
 IRO25 { 1,0,0,255,0,0,64,0,0 }
 ERA25 { 0,0,0,0,0,32,4,0,0 }
 XRA25 { 0,0,0,0,0,0,0,0,0 }
 OCM251 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 C251F1=19476544
 C251F2=0
 C251MSC (I4)
 C251DEF ()
 C251UDF ()
 INCC2 (..\..\..\psp_rel\inc;..\..\inc)
 AX51FL=4
 AX51MSC (I4)
 AX51SET ()
 AX51RST ()
 INCA5 (..\..\inc;..\..\..\psp_rel\inc)
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=301
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI (.\ap_alarm.lin)
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S251.DLL)(-Flip251)(DP51.DLL)(-p251S -dactsim)(S251.DLL)()(TP51.DLL)(-p251S)
  OPTDBG 47610,1,()()()()(.\bromsim.dini.ini)()()()()() (C:\Program Files\ATD_V2.1\UDI\ActsAGDI.dll)()()()
 FLASH1 { 1,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

